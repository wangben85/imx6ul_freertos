# IAR project dvfs_simulation.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6G3DVM05; PRINTF_FLOAT_ENABLE=1; EVK_MCIMX6UL; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CORTEXA/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MCIMX6G3/drivers; ../../../../../devices/MCIMX6G3/utilities; ../../../../../devices/MCIMX6G3; ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9; ../../../../../rtos/freertos_9.0.0/Source/include; ../../../../../rtos/freertos_9.0.0/Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ../../..
  OBJCOPY.OOCOutputFile: dvfs_simulation.bin
  ILINK.IlinkOutputFile: dvfs_simulation.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MCIMX6G3DVM05; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: ../../../../../CORTEXA/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MCIMX6G3/drivers; ../../../../../devices/MCIMX6G3/utilities; ../../../../../devices/MCIMX6G3
  AARM.ADefines: DEBUG
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MCIMX6G3DVM05; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX6G3DVM05; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h clock_config_ocram.c pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MCIMX6G3/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_uart.c fsl_uart.h
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/IAR/ARM_CA9/: fsl_tickless_epit.c fsl_tickless_generic.h port.c portASM.h portASM.s portmacro.h
  group source
    ../: dvfs_simulation.c FreeRTOSConfig.h
  group startup
    ../../../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
    ../../../../../devices/MCIMX6G3/: system_MCIMX6G3.c system_MCIMX6G3.h
  group utilities
    ../../../../../devices/MCIMX6G3/utilities/: fsl_debug_console.c fsl_debug_console.h
