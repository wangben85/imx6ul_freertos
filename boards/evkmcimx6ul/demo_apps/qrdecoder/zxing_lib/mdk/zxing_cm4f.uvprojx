# Keil uVision project zxing_cm4f.uvprojx, settings and files
target zxing (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta4
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: zxing_cm4f (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: NO_ICONV
  c misc: --diag_suppress=1296,186,1300,177,61,68,611 --exceptions
  c include: ..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group zxing
    ../src/zxing/: BarcodeFormat.cpp Binarizer.cpp BinaryBitmap.cpp ChecksumException.cpp DecodeHints.cpp Exception.cpp FormatException.cpp LuminanceSource.cpp MultiFormatReader.cpp Reader.cpp Result.cpp ResultIO.cpp ResultPoint.cpp ResultPointCallback.cpp
  group zxing/common
    ../src/zxing/common/: BitArray.cpp BitArrayIO.cpp BitMatrix.cpp BitSource.cpp CharacterSetECI.cpp DecoderResult.cpp DetectorResult.cpp FastHybridBinarizer.cpp GlobalHistogramBinarizer.cpp GridSampler.cpp HybridBinarizer.cpp IllegalArgumentException.cpp PerspectiveTransform.cpp Str.cpp StringUtils.cpp
  group zxing/bridge
    ../src/: main_bridge.cpp image_keil.s
  group zxing/oned
    ../src/zxing/oned/: OneDReader.cpp OneDResultPoint.cpp UPCAReader.cpp UPCEANReader.cpp UPCEReader.cpp CodaBarReader.cpp Code39Reader.cpp Code93Reader.cpp Code128Reader.cpp EAN8Reader.cpp EAN13Reader.cpp ITFReader.cpp MultiFormatOneDReader.cpp MultiFormatUPCEANReader.cpp
  group zxing\qrcode\detector
    ../src/zxing/qrcode/detector/: AlignmentPattern.cpp AlignmentPatternFinder.cpp Detector.cpp FinderPattern.cpp FinderPatternFinder.cpp FinderPatternInfo.cpp
  group zxing\qrocode\decoder
    ../src/zxing/qrcode/decoder/: BitMatrixParser.cpp DataBlock.cpp DataMask.cpp DecodedBitStreamParser.cpp Decoder.cpp Mode.cpp
  group zxing\qrcode
    ../src/zxing/qrcode/: ErrorCorrectionLevel.cpp FormatInformation.cpp QRCodeReader.cpp Version.cpp
  group zxing\qrcode\reedsolomon
    ../src/zxing/common/reedsolomon/: GenericGF.cpp GenericGFPoly.cpp ReedSolomonDecoder.cpp ReedSolomonException.cpp
