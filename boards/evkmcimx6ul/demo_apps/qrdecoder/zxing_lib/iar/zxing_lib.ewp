# IAR project zxing_lib.ewp, settings and files
configuration CM4 (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: NDEBUG; NO_ICONV
  ICCARM.CCDiagSuppress: Pe611,Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../src/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: zxing_lib.bin
  ILINK.IlinkOutputFile: qrdecode_zxing.out
  ILINK.IlinkConfigDefines: __stack_size__=0x0800; __heap_size__=0x2F000
  ILINK.IlinkIcfFile: ../../../mcu-sdk/platform/devices/MK80F25615/linker/iar/MK80FN256xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../mcu-sdk/lib/ksdk_platform_lib/iar/K80F25615/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A7 (ARM, debug)
  as the first configuration, except:
  group source
    ../src/: image.s main_bridge.cpp
  group zxing
    ../src/zxing/: BarcodeFormat.cpp BarcodeFormat.h Binarizer.cpp Binarizer.h BinaryBitmap.cpp BinaryBitmap.h ChecksumException.cpp ChecksumException.h DecodeHints.cpp DecodeHints.h Exception.cpp Exception.h FormatException.cpp FormatException.h IllegalStateException.h LuminanceSource.cpp LuminanceSource.h MultiFormatReader.cpp MultiFormatReader.h NotFoundException.h Reader.cpp Reader.h ReaderException.h Result.cpp Result.h ResultIO.cpp ResultPoint.cpp ResultPoint.h ResultPointCallback.cpp ResultPointCallback.h ZXing.h
  group zxing/common
    ../src/zxing/common/: Array.h BitArray.cpp BitArray.h BitArrayIO.cpp BitMatrix.cpp BitMatrix.h BitSource.cpp BitSource.h CharacterSetECI.cpp CharacterSetECI.h Counted.h DecoderResult.cpp DecoderResult.h DetectorResult.cpp DetectorResult.h FastHybridBinarizer.cpp FastHybridBinarizer.h GlobalHistogramBinarizer.cpp GlobalHistogramBinarizer.h GridSampler.cpp GridSampler.h HybridBinarizer.cpp HybridBinarizer.h IllegalArgumentException.cpp IllegalArgumentException.h PerspectiveTransform.cpp PerspectiveTransform.h Point.h Str.cpp Str.h StringUtils.cpp StringUtils.h
  group zxing/common/detector
    ../src/zxing/common/detector/: MathUtils.h
  group zxing/common/reedsolomon
    ../src/zxing/common/reedsolomon/: GenericGF.cpp GenericGF.h GenericGFPoly.cpp GenericGFPoly.h ReedSolomonDecoder.cpp ReedSolomonDecoder.h ReedSolomonException.cpp ReedSolomonException.h
  group zxing/multi
    ../src/zxing/multi/: ByQuadrantReader.cpp ByQuadrantReader.h GenericMultipleBarcodeReader.cpp GenericMultipleBarcodeReader.h MultipleBarcodeReader.cpp MultipleBarcodeReader.h
  group zxing/multi/qrcode
    ../src/zxing/multi/qrcode/detector/: MultiDetector.cpp MultiDetector.h MultiFinderPatternFinder.cpp MultiFinderPatternFinder.h
    ../src/zxing/multi/qrcode/: QRCodeMultiReader.cpp QRCodeMultiReader.h
  group zxing/oned
    ../src/zxing/oned/: CodaBarReader.cpp CodaBarReader.h Code128Reader.cpp Code128Reader.h Code39Reader.cpp Code39Reader.h Code93Reader.cpp Code93Reader.h EAN13Reader.cpp EAN13Reader.h EAN8Reader.cpp EAN8Reader.h ITFReader.cpp ITFReader.h MultiFormatOneDReader.cpp MultiFormatOneDReader.h MultiFormatUPCEANReader.cpp MultiFormatUPCEANReader.h OneDReader.cpp OneDReader.h OneDResultPoint.cpp OneDResultPoint.h UPCAReader.cpp UPCAReader.h UPCEANReader.cpp UPCEANReader.h UPCEReader.cpp UPCEReader.h
  group zxing/qrcode
    ../src/zxing/qrcode/: ErrorCorrectionLevel.cpp ErrorCorrectionLevel.h FormatInformation.cpp FormatInformation.h QRCodeReader.cpp QRCodeReader.h Version.cpp Version.h
  group zxing/qrcode/decoder
    ../src/zxing/qrcode/decoder/: BitMatrixParser.cpp BitMatrixParser.h DataBlock.cpp DataBlock.h DataMask.cpp DataMask.h DecodedBitStreamParser.cpp DecodedBitStreamParser.h Decoder.cpp Decoder.h Mode.cpp Mode.h
  group zxing/qrcode/detector
    ../src/zxing/qrcode/detector/: AlignmentPattern.cpp AlignmentPattern.h AlignmentPatternFinder.cpp AlignmentPatternFinder.h Detector.cpp Detector.h FinderPattern.cpp FinderPattern.h FinderPatternFinder.cpp FinderPatternFinder.h FinderPatternInfo.cpp FinderPatternInfo.h
