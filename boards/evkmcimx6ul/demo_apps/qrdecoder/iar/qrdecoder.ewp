# IAR project qrdecoder.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6G3DVM05; APP_USE_CAMERA=1; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX6UL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CORTEXA/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MCIMX6G3/drivers; ../../../../../devices/MCIMX6G3/utilities; ../../../../../devices/MCIMX6G3; ../../../../../../devices/MCIMX6G3/utilities; ../../../../../../devices/MCIMX6G3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: qrdecoder.bin
  ILINK.IlinkOutputFile: qrdecoder.out
  ILINK.IlinkConfigDefines: __stack_size__=0x0A00; __heap_size__=0x2F000
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MCIMX6G3DVM05; APP_USE_CAMERA=1; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: ../../../../../../CORTEXA/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../devices/MCIMX6G3/drivers; ../../../../../../devices/MCIMX6G3/utilities; ../../../../../../devices/MCIMX6G3
  AARM.ADefines: DEBUG
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MCIMX6G3DVM05; APP_USE_CAMERA=1; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX6G3DVM05; APP_USE_CAMERA=1; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h clock_config_ocram.c pin_mux.c pin_mux.h
  group camera
    ../: fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h fsl_ov5640.c fsl_ov5640.h fsl_sccb.c fsl_sccb.h fsl_video_common.h
  group drivers
    ../../../../../devices/MCIMX6G3/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_iomuxc.h fsl_pxp.c fsl_pxp.h fsl_uart.c fsl_uart.h
  group drivers/doc
    ../: readme.txt
  group source
    ../: qrdecoder_rgb.c qrdecoder_yuv.c zxing_bridge.h zxing_lib.a
  group startup
    ../../../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
    ../../../../../devices/MCIMX6G3/: system_MCIMX6G3.c system_MCIMX6G3.h
  group utilities
    ../../../../../devices/MCIMX6G3/utilities/: fsl_debug_console.c fsl_debug_console.h
