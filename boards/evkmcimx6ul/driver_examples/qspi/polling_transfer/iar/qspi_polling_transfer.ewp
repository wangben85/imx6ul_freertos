# IAR project qspi_polling_transfer.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6G3DVM05; EVK_MCIMX6UL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CORTEXA/Include; ../../../../../../devices; ..; ../../../..; ../../../../../../devices/MCIMX6G3/drivers; ../../../../../../devices/MCIMX6G3/utilities; ../../../../../../devices/MCIMX6G3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: qspi_polling_transfer.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
    ../../../../../../devices/MCIMX6G3/: system_MCIMX6G3.c system_MCIMX6G3.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MCIMX6G3/drivers/: fsl_uart.h fsl_uart.c fsl_clock.h fsl_clock.c fsl_qspi.h fsl_qspi.c fsl_common.h fsl_common.c fsl_iomuxc.h
  group source
    ../: qspi_polling_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config_ocram.c clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MCIMX6G3/utilities/: fsl_debug_console.c fsl_debug_console.h
