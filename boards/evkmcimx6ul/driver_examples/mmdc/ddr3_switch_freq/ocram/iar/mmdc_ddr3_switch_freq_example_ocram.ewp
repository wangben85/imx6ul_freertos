# IAR project mmdc_ddr3_switch_freq_example_ocram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: DEBUG; CPU_MCIMX6G3DVM05; EVK_MCIMX6UL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../CORTEXA/Include; ../../../../../../../devices; ..; ../../../../..; ../../../../../../../devices/MCIMX6G3/drivers; ../../../../../../../devices/MCIMX6G3/utilities; ../../../../../../../devices/MCIMX6G3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: mmdc_ddr3_switch_freq_example_ocram.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX6G3DVM05; EVK_MCIMX6UL
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MCIMX6G3/iar/: startup_MCIMX6G3.s
    ../../../../../../../devices/MCIMX6G3/: system_MCIMX6G3.c system_MCIMX6G3.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MCIMX6G3/drivers/: fsl_uart.h fsl_uart.c fsl_mmdc.h fsl_mmdc.c fsl_common.h fsl_common.c fsl_iomuxc.h fsl_clock.h fsl_clock.c
  group source
    ../: mmdc_ddr3_switch_freq_example.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config_ocram.c clock_config.c clock_config.h
    ../../: mmdc_ddr3_switchfreq.s
  group utilities
    ../../../../../../../devices/MCIMX6G3/utilities/: fsl_debug_console.c fsl_debug_console.h
